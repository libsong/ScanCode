# Keil uVision project APP_Project.uvproj, settings and files
target APP_Project (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: user_lib-v1-1 +hex
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG_Print,IWATCHCDOG_ENABLE,XP10
  c include: .\App;.\Cmsis\startup;.\FWlib\inc;.\FWlib\src;.\User\TASK\src;.\User\USER_API\src;.\User\USER_API\inc;.\User\TASK\inc;.\User\TASK\inc;.\User\Malloc;.\User\USER_API\inc;.\Cmsis
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./User/TASK/src/: main.c
  group Cmsis
    ./Cmsis/: core_cm3.c system_stm32f10x.c
    ./Cmsis/startup/: startup_stm32f10x_hd.s
  group FWlib
    ./FWlib/src/: app_project.lib
  group User
    ./User/USER_API/src/: user_lib.lib stm32f10x_it.c user_delay.c user_scan.c user_time.c user_print.c we_do.c
  group Malloc
    ./User/Malloc/: malloc.c
  group direction
    ./User/direction/: direction.txt
    ./: questions.txt
    ../: test.txt
